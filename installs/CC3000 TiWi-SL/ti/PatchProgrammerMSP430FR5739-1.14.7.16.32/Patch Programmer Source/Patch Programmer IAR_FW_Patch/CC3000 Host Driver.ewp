# IAR project CC3000 Host Driver.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CC3000_TINY_DRIVER; CC3000_UNENCRYPTED_SMART_CONFIG
  ICC430.CCDiagSuppress: Pa039
  ICC430.newCCIncludePaths: ..\Source\CC3000HostDriver; ..\Source\\inc
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  group (top)
    ../Source/CC3000HostDriver/: cc3000_common.c cc3000_common.h error_codes.h evnt_handler.c evnt_handler.h hci.c hci.h host_driver_version.h netapp.c netapp.h nvmem.c nvmem.h security.c security.h socket.c socket.h wlan.c wlan.h
